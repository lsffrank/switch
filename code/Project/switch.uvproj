# Keil uVision project switch.uvproj, settings and files
target switch (ARM-ADS)
  device: M0516LBN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: switch
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c include: ..\Library\StdDriver\inc;..\Library\CMSIS\CM0\CoreSupport;..\Library\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../Library/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/startup/arm/: startup_M051Series.s
    ../Library/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/: system_M051Series.c
  group Source
    ../src/: main.c
  group Library
    ../Library/StdDriver/src/: retarget.c
